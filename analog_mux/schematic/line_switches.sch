v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 650 2350 780 2350 { lab=#net1}
N 500 2350 550 2350 { lab=in10}
N 650 2550 780 2550 { lab=#net2}
N 500 2550 550 2550 { lab=in11}
N 900 2550 1020 2550 { lab=out}
N 650 2750 780 2750 { lab=#net3}
N 500 2750 550 2750 { lab=in12}
N 900 2750 1020 2750 { lab=out}
N 900 2350 1020 2350 { lab=out}
N 650 2950 780 2950 { lab=#net4}
N 500 2950 550 2950 { lab=in13}
N 650 3150 780 3150 { lab=#net5}
N 500 3150 550 3150 { lab=in14}
N 900 3150 1020 3150 { lab=out}
N 650 3350 780 3350 { lab=#net6}
N 500 3350 550 3350 { lab=in15}
N 900 3350 1020 3350 { lab=out}
N 900 2950 1020 2950 { lab=out}
N 650 3550 780 3550 { lab=#net7}
N 500 3550 550 3550 { lab=in16}
N 900 3550 1020 3550 { lab=out}
N 650 3750 780 3750 { lab=#net8}
N 500 3750 550 3750 { lab=in17}
N 900 3750 1020 3750 { lab=out}
N 650 3950 780 3950 { lab=#net9}
N 500 3950 550 3950 { lab=in18}
N 650 4150 780 4150 { lab=#net10}
N 500 4150 550 4150 { lab=in19}
N 900 4150 1020 4150 { lab=out}
N 900 3950 1020 3950 { lab=out}
N 650 1150 780 1150 { lab=#net11}
N 500 1150 550 1150 { lab=in4}
N 900 1150 1020 1150 { lab=out}
N 650 1350 780 1350 { lab=#net12}
N 500 1350 550 1350 { lab=in5}
N 900 1350 1020 1350 { lab=out}
N 650 1550 780 1550 { lab=#net13}
N 500 1550 550 1550 { lab=in6}
N 900 1550 1020 1550 { lab=out}
N 650 1750 780 1750 { lab=#net14}
N 500 1750 550 1750 { lab=in7}
N 900 1750 1020 1750 { lab=out}
N 650 1950 780 1950 { lab=#net15}
N 500 1950 550 1950 { lab=in8}
N 650 2150 780 2150 { lab=#net16}
N 500 2150 550 2150 { lab=in9}
N 900 2150 1020 2150 { lab=out}
N 900 1950 1020 1950 { lab=out}
N 650 550 780 550 { lab=#net17}
N 500 550 550 550 { lab=in1}
N 900 550 1020 550 { lab=out}
N 650 750 780 750 { lab=#net18}
N 500 750 550 750 { lab=in2}
N 900 750 1020 750 { lab=out}
N 650 950 780 950 { lab=#net19}
N 500 950 550 950 { lab=in3}
N 900 950 1020 950 { lab=out}
N 1020 550 1020 950 { lab=out}
N 1020 350 1120 350 { lab=out}
N 650 350 780 350 { lab=#net20}
N 500 350 550 350 { lab=in0}
N 900 350 1020 350 { lab=out}
N 1020 350 1020 550 { lab=out}
N 1020 950 1020 4150 { lab=out}
N 1120 350 1180 350 { lab=out}
N 400 350 500 350 { lab=in0}
N 400 550 500 550 { lab=in1}
N 410 750 500 750 { lab=in2}
N 410 950 500 950 { lab=in3}
N 410 1150 500 1150 { lab=in4}
N 410 1350 500 1350 { lab=in5}
N 410 1550 500 1550 { lab=in6}
N 410 1750 500 1750 { lab=in7}
N 410 1950 500 1950 { lab=in8}
N 410 2150 500 2150 { lab=in9}
N 410 2350 500 2350 { lab=in10}
N 410 2550 500 2550 { lab=in11}
N 410 2750 500 2750 { lab=in12}
N 410 2950 500 2950 { lab=in13}
N 410 3150 500 3150 { lab=in14}
N 410 3350 500 3350 { lab=in15}
N 410 3550 500 3550 { lab=in16}
N 410 3750 500 3750 { lab=in17}
N 410 3950 500 3950 { lab=in18}
N 410 4150 500 4150 { lab=in19}
N 80 280 120 280 {}
N 80 260 120 260 {}
N 650 4360 780 4360 { lab=#net10}
N 500 4360 550 4360 { lab=in19}
N 900 4360 1020 4360 { lab=out}
N 410 4360 500 4360 { lab=in19}
N 650 4570 780 4570 { lab=#net10}
N 500 4570 550 4570 { lab=in19}
N 900 4570 1020 4570 { lab=out}
N 410 4570 500 4570 { lab=in19}
N 650 4780 780 4780 { lab=#net10}
N 500 4780 550 4780 { lab=in19}
N 900 4780 1020 4780 { lab=out}
N 410 4780 500 4780 { lab=in19}
N 650 4990 780 4990 { lab=#net10}
N 500 4990 550 4990 { lab=in19}
N 900 4990 1020 4990 { lab=out}
N 410 4990 500 4990 { lab=in19}
N 650 5200 780 5200 { lab=#net10}
N 500 5200 550 5200 { lab=in19}
N 900 5200 1020 5200 { lab=out}
N 410 5200 500 5200 { lab=in19}
N 650 5410 780 5410 { lab=#net10}
N 500 5410 550 5410 { lab=in19}
N 900 5410 1020 5410 { lab=out}
N 410 5410 500 5410 { lab=in19}
N 650 5620 780 5620 { lab=#net10}
N 500 5620 550 5620 { lab=in19}
N 900 5620 1020 5620 { lab=out}
N 410 5620 500 5620 { lab=in19}
N 650 5830 780 5830 { lab=#net10}
N 500 5830 550 5830 { lab=in19}
N 900 5830 1020 5830 { lab=out}
N 410 5830 500 5830 { lab=in19}
N 650 6040 780 6040 { lab=#net10}
N 500 6040 550 6040 { lab=in19}
N 900 6040 1020 6040 { lab=out}
N 410 6040 500 6040 { lab=in19}
N 650 6250 780 6250 { lab=#net10}
N 500 6250 550 6250 { lab=in19}
N 900 6250 1020 6250 { lab=out}
N 410 6250 500 6250 { lab=in19}
N 650 6460 780 6460 { lab=#net10}
N 500 6460 550 6460 { lab=in19}
N 900 6460 1020 6460 { lab=out}
N 410 6460 500 6460 { lab=in19}
N 650 6670 780 6670 { lab=#net10}
N 500 6670 550 6670 { lab=in19}
N 900 6670 1020 6670 { lab=out}
N 410 6670 500 6670 { lab=in19}
N 1020 4150 1020 6670 {}
C {transmission_gate.sym} 570 2350 0 0 {name=x28 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 2300 2 1 {name=x29 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 2390 2 0 {name=l46 sig_type=std_logic lab=en10_b
}
C {devices/lab_pin.sym} 840 2230 2 0 {name=l47 sig_type=std_logic lab=en10_b
}
C {devices/lab_pin.sym} 600 2310 0 0 {name=l48 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 2390 0 0 {name=l49 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 2550 0 0 {name=x31 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 2500 2 1 {name=x32 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 2590 2 0 {name=l51 sig_type=std_logic lab=en11_b
}
C {devices/lab_pin.sym} 840 2430 2 0 {name=l52 sig_type=std_logic lab=en11_b
}
C {devices/lab_pin.sym} 600 2510 0 0 {name=l53 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 2590 0 0 {name=l54 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 2750 0 0 {name=x34 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 2700 2 1 {name=x35 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 2790 2 0 {name=l56 sig_type=std_logic lab=en12_b
}
C {devices/lab_pin.sym} 840 2630 2 0 {name=l57 sig_type=std_logic lab=en12_b
}
C {devices/lab_pin.sym} 600 2710 0 0 {name=l58 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 2790 0 0 {name=l59 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 2950 0 0 {name=x37 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 2900 2 1 {name=x38 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 2990 2 0 {name=l61 sig_type=std_logic lab=en13_b
}
C {devices/lab_pin.sym} 840 2830 2 0 {name=l62 sig_type=std_logic lab=en13_b
}
C {devices/lab_pin.sym} 600 2910 0 0 {name=l63 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 2990 0 0 {name=l64 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 3150 0 0 {name=x40 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 3100 2 1 {name=x41 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 3190 2 0 {name=l66 sig_type=std_logic lab=en14_b
}
C {devices/lab_pin.sym} 840 3030 2 0 {name=l67 sig_type=std_logic lab=en14_b
}
C {devices/lab_pin.sym} 600 3110 0 0 {name=l68 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 3190 0 0 {name=l69 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 3350 0 0 {name=x43 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 3300 2 1 {name=x44 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 3390 2 0 {name=l71 sig_type=std_logic lab=en15_b
}
C {devices/lab_pin.sym} 840 3230 2 0 {name=l72 sig_type=std_logic lab=en15_b
}
C {devices/lab_pin.sym} 600 3310 0 0 {name=l73 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 3390 0 0 {name=l74 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 3550 0 0 {name=x46 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 3500 2 1 {name=x47 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 3590 2 0 {name=l76 sig_type=std_logic lab=en16_b
}
C {devices/lab_pin.sym} 840 3430 2 0 {name=l77 sig_type=std_logic lab=en16_b
}
C {devices/lab_pin.sym} 600 3510 0 0 {name=l78 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 3590 0 0 {name=l79 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 3750 0 0 {name=x49 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 3700 2 1 {name=x50 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 3790 2 0 {name=l81 sig_type=std_logic lab=en17_b
}
C {devices/lab_pin.sym} 840 3630 2 0 {name=l82 sig_type=std_logic lab=en17_b
}
C {devices/lab_pin.sym} 600 3710 0 0 {name=l83 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 3790 0 0 {name=l84 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 3950 0 0 {name=x52 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 3900 2 1 {name=x53 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 3990 2 0 {name=l86 sig_type=std_logic lab=en18_b
}
C {devices/lab_pin.sym} 840 3830 2 0 {name=l87 sig_type=std_logic lab=en18_b
}
C {devices/lab_pin.sym} 600 3910 0 0 {name=l88 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 3990 0 0 {name=l89 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 4150 0 0 {name=x55 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 4100 2 1 {name=x56 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 4190 2 0 {name=l91 sig_type=std_logic lab=en19_b
}
C {devices/lab_pin.sym} 840 4030 2 0 {name=l92 sig_type=std_logic lab=en19_b
}
C {devices/lab_pin.sym} 600 4110 0 0 {name=l93 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 4190 0 0 {name=l94 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 1150 0 0 {name=x2 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 1100 2 1 {name=x3 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 1190 2 0 {name=l1 sig_type=std_logic lab=en4_b
}
C {devices/lab_pin.sym} 840 1030 2 0 {name=l2 sig_type=std_logic lab=en4_b
}
C {devices/lab_pin.sym} 600 1110 0 0 {name=l3 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 1190 0 0 {name=l4 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 1350 0 0 {name=x5 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 1300 2 1 {name=x6 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 1390 2 0 {name=l6 sig_type=std_logic lab=en5_b
}
C {devices/lab_pin.sym} 840 1230 2 0 {name=l7 sig_type=std_logic lab=en5_b
}
C {devices/lab_pin.sym} 600 1310 0 0 {name=l8 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 1390 0 0 {name=l9 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 1550 0 0 {name=x8 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 1500 2 1 {name=x9 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 1590 2 0 {name=l11 sig_type=std_logic lab=en6_b
}
C {devices/lab_pin.sym} 840 1430 2 0 {name=l12 sig_type=std_logic lab=en6_b
}
C {devices/lab_pin.sym} 600 1510 0 0 {name=l13 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 1590 0 0 {name=l14 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 1750 0 0 {name=x11 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 1700 2 1 {name=x12 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 1790 2 0 {name=l16 sig_type=std_logic lab=en7_b
}
C {devices/lab_pin.sym} 840 1630 2 0 {name=l17 sig_type=std_logic lab=en7_b
}
C {devices/lab_pin.sym} 600 1710 0 0 {name=l18 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 1790 0 0 {name=l19 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 1950 0 0 {name=x14 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 1900 2 1 {name=x15 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 1990 2 0 {name=l21 sig_type=std_logic lab=en8_b
}
C {devices/lab_pin.sym} 840 1830 2 0 {name=l22 sig_type=std_logic lab=en8_b
}
C {devices/lab_pin.sym} 600 1910 0 0 {name=l23 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 1990 0 0 {name=l24 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 2150 0 0 {name=x17 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 2100 2 1 {name=x18 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 2190 2 0 {name=l26 sig_type=std_logic lab=en9_b
}
C {devices/lab_pin.sym} 840 2030 2 0 {name=l27 sig_type=std_logic lab=en9_b
}
C {devices/lab_pin.sym} 600 2110 0 0 {name=l28 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 2190 0 0 {name=l29 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 550 0 0 {name=x20 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 500 2 1 {name=x21 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 590 2 0 {name=l31 sig_type=std_logic lab=en1_b
}
C {devices/lab_pin.sym} 840 430 2 0 {name=l32 sig_type=std_logic lab=en1_b
}
C {devices/lab_pin.sym} 600 510 0 0 {name=l33 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 590 0 0 {name=l34 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 750 0 0 {name=x23 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 700 2 1 {name=x24 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 790 2 0 {name=l36 sig_type=std_logic lab=en2_b
}
C {devices/lab_pin.sym} 840 630 2 0 {name=l37 sig_type=std_logic lab=en2_b
}
C {devices/lab_pin.sym} 600 710 0 0 {name=l38 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 790 0 0 {name=l39 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 950 0 0 {name=x26 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 900 2 1 {name=x27 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 990 2 0 {name=l41 sig_type=std_logic lab=en3_b
}
C {devices/lab_pin.sym} 840 830 2 0 {name=l42 sig_type=std_logic lab=en3_b
}
C {devices/lab_pin.sym} 600 910 0 0 {name=l43 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 990 0 0 {name=l44 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 350 0 0 {name=x59 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 300 2 1 {name=x60 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 390 2 0 {name=l96 sig_type=std_logic lab=en0_b
}
C {devices/lab_pin.sym} 840 230 2 0 {name=l97 sig_type=std_logic lab=en0_b
}
C {devices/lab_pin.sym} 600 310 0 0 {name=l98 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 390 0 0 {name=l99 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 1350 0 0 {name=p32 lab=in5





}
C {devices/ipin.sym} 420 1550 0 0 {name=p33 lab=in6






}
C {devices/ipin.sym} 420 1750 0 0 {name=p34 lab=in7







}
C {devices/ipin.sym} 420 1950 0 0 {name=p35 lab=in8








}
C {devices/ipin.sym} 420 2150 0 0 {name=p36 lab=in9









}
C {devices/ipin.sym} 420 2350 0 0 {name=p37 lab=in10










}
C {devices/ipin.sym} 420 2550 0 0 {name=p38 lab=in11










}
C {devices/ipin.sym} 420 2750 0 0 {name=p39 lab=in12










}
C {devices/ipin.sym} 420 2950 0 0 {name=p40 lab=in13










}
C {devices/ipin.sym} 420 3150 0 0 {name=p41 lab=in14










}
C {devices/ipin.sym} 420 3350 0 0 {name=p42 lab=in15










}
C {devices/ipin.sym} 420 3550 0 0 {name=p43 lab=in16











}
C {devices/ipin.sym} 420 3750 0 0 {name=p44 lab=in17













}
C {devices/ipin.sym} 420 3950 0 0 {name=p45 lab=in18














}
C {devices/ipin.sym} 420 4150 0 0 {name=p46 lab=in19















}
C {devices/opin.sym} 1170 350 0 0 {name=p21 lab=out}
C {devices/ipin.sym} 410 350 0 0 {name=p27 lab=in0
}
C {devices/ipin.sym} 410 550 0 0 {name=p28 lab=in1

}
C {devices/ipin.sym} 420 750 0 0 {name=p29 lab=in2


}
C {devices/ipin.sym} 420 950 0 0 {name=p30 lab=in3



}
C {devices/ipin.sym} 420 1150 0 0 {name=p31 lab=in4




}
C {devices/ipin.sym} 90 350 0 0 {name=p1 lab=en0_b
}
C {devices/ipin.sym} 90 380 0 0 {name=p2 lab=en1_b

}
C {devices/ipin.sym} 90 410 0 0 {name=p3 lab=en2_b


}
C {devices/ipin.sym} 90 440 0 0 {name=p4 lab=en3_b


}
C {devices/ipin.sym} 90 470 0 0 {name=p5 lab=en4_b


}
C {devices/ipin.sym} 90 500 0 0 {name=p6 lab=en5_b


}
C {devices/ipin.sym} 90 530 0 0 {name=p7 lab=en6_b


}
C {devices/ipin.sym} 90 560 0 0 {name=p8 lab=en7_b


}
C {devices/ipin.sym} 90 590 0 0 {name=p9 lab=en8_b


}
C {devices/ipin.sym} 90 620 0 0 {name=p10 lab=en9_b


}
C {devices/ipin.sym} 90 650 0 0 {name=p11 lab=en10_b


}
C {devices/ipin.sym} 90 680 0 0 {name=p12 lab=en11_b


}
C {devices/ipin.sym} 90 710 0 0 {name=p13 lab=en12_b


}
C {devices/ipin.sym} 90 740 0 0 {name=p14 lab=en13_b


}
C {devices/ipin.sym} 90 770 0 0 {name=p15 lab=en14_b


}
C {devices/ipin.sym} 90 800 0 0 {name=p16 lab=en15_b


}
C {devices/ipin.sym} 90 830 0 0 {name=p17 lab=en16_b


}
C {devices/ipin.sym} 90 860 0 0 {name=p18 lab=en17_b


}
C {devices/ipin.sym} 90 890 0 0 {name=p19 lab=en18_b


}
C {devices/ipin.sym} 90 920 0 0 {name=p20 lab=en19_b


}
C {devices/ipin.sym} 90 950 0 0 {name=p22 lab=en20_b


}
C {devices/ipin.sym} 90 980 0 0 {name=p23 lab=en21_b


}
C {devices/ipin.sym} 90 1010 0 0 {name=p24 lab=en22_b


}
C {devices/ipin.sym} 90 1040 0 0 {name=p25 lab=en23_b


}
C {devices/ipin.sym} 90 1070 0 0 {name=p26 lab=en24_b


}
C {devices/ipin.sym} 90 1100 0 0 {name=p47 lab=en25_b


}
C {devices/ipin.sym} 90 1130 0 0 {name=p48 lab=en26_b


}
C {devices/ipin.sym} 90 1160 0 0 {name=p49 lab=en27_b


}
C {devices/ipin.sym} 90 1190 0 0 {name=p50 lab=en28_b


}
C {devices/ipin.sym} 90 1220 0 0 {name=p51 lab=en29_b


}
C {devices/ipin.sym} 90 1250 0 0 {name=p52 lab=en30_b


}
C {devices/ipin.sym} 90 1280 0 0 {name=p53 lab=en31_b


}
C {devices/ipin.sym} 90 280 0 0 {name=p54 lab=en_b

}
C {devices/ipin.sym} 90 260 0 0 {name=p55 lab=en


}
C {devices/lab_pin.sym} 120 280 2 0 {name=l5 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 120 260 2 0 {name=l10 sig_type=std_logic lab=en
}
C {transmission_gate.sym} 570 4360 0 0 {name=x1 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 4310 2 1 {name=x62 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 4400 2 0 {name=l15 sig_type=std_logic lab=en20_b
}
C {devices/lab_pin.sym} 840 4240 2 0 {name=l20 sig_type=std_logic lab=en20_b
}
C {devices/lab_pin.sym} 600 4320 0 0 {name=l25 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 4400 0 0 {name=l30 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 4360 0 0 {name=p56 lab=in20















}
C {transmission_gate.sym} 570 4570 0 0 {name=x64 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 4520 2 1 {name=x65 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 4610 2 0 {name=l35 sig_type=std_logic lab=en21_b
}
C {devices/lab_pin.sym} 840 4450 2 0 {name=l40 sig_type=std_logic lab=en21_b
}
C {devices/lab_pin.sym} 600 4530 0 0 {name=l45 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 4610 0 0 {name=l50 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 4570 0 0 {name=p57 lab=in21















}
C {transmission_gate.sym} 570 4780 0 0 {name=x67 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 4730 2 1 {name=x68 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 4820 2 0 {name=l55 sig_type=std_logic lab=en22_b
}
C {devices/lab_pin.sym} 840 4660 2 0 {name=l60 sig_type=std_logic lab=en22_b
}
C {devices/lab_pin.sym} 600 4740 0 0 {name=l65 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 4820 0 0 {name=l70 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 4780 0 0 {name=p58 lab=in22















}
C {transmission_gate.sym} 570 4990 0 0 {name=x70 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 4940 2 1 {name=x71 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 5030 2 0 {name=l75 sig_type=std_logic lab=en23_b
}
C {devices/lab_pin.sym} 840 4870 2 0 {name=l80 sig_type=std_logic lab=en23_b
}
C {devices/lab_pin.sym} 600 4950 0 0 {name=l85 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 5030 0 0 {name=l90 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 4990 0 0 {name=p59 lab=in23















}
C {transmission_gate.sym} 570 5200 0 0 {name=x73 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 5150 2 1 {name=x74 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 5240 2 0 {name=l95 sig_type=std_logic lab=en24_b
}
C {devices/lab_pin.sym} 840 5080 2 0 {name=l100 sig_type=std_logic lab=en24_b
}
C {devices/lab_pin.sym} 600 5160 0 0 {name=l101 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 5240 0 0 {name=l102 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 5200 0 0 {name=p60 lab=in24















}
C {transmission_gate.sym} 570 5410 0 0 {name=x76 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 5360 2 1 {name=x77 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 5450 2 0 {name=l103 sig_type=std_logic lab=en25_b
}
C {devices/lab_pin.sym} 840 5290 2 0 {name=l104 sig_type=std_logic lab=en25_b
}
C {devices/lab_pin.sym} 600 5370 0 0 {name=l105 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 5450 0 0 {name=l106 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 5410 0 0 {name=p61 lab=in25















}
C {transmission_gate.sym} 570 5620 0 0 {name=x79 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 5570 2 1 {name=x80 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 5660 2 0 {name=l107 sig_type=std_logic lab=en26_b
}
C {devices/lab_pin.sym} 840 5500 2 0 {name=l108 sig_type=std_logic lab=en26_b
}
C {devices/lab_pin.sym} 600 5580 0 0 {name=l109 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 5660 0 0 {name=l110 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 5620 0 0 {name=p62 lab=in26















}
C {transmission_gate.sym} 570 5830 0 0 {name=x82 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 5780 2 1 {name=x83 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 5870 2 0 {name=l111 sig_type=std_logic lab=en27_b
}
C {devices/lab_pin.sym} 840 5710 2 0 {name=l112 sig_type=std_logic lab=en27_b
}
C {devices/lab_pin.sym} 600 5790 0 0 {name=l113 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 5870 0 0 {name=l114 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 5830 0 0 {name=p63 lab=in27















}
C {transmission_gate.sym} 570 6040 0 0 {name=x85 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 5990 2 1 {name=x86 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 6080 2 0 {name=l115 sig_type=std_logic lab=en28_b
}
C {devices/lab_pin.sym} 840 5920 2 0 {name=l116 sig_type=std_logic lab=en28_b
}
C {devices/lab_pin.sym} 600 6000 0 0 {name=l117 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 6080 0 0 {name=l118 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 6040 0 0 {name=p64 lab=in28















}
C {transmission_gate.sym} 570 6250 0 0 {name=x88 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 6200 2 1 {name=x89 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 6290 2 0 {name=l119 sig_type=std_logic lab=en29_b
}
C {devices/lab_pin.sym} 840 6130 2 0 {name=l120 sig_type=std_logic lab=en29_b
}
C {devices/lab_pin.sym} 600 6210 0 0 {name=l121 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 6290 0 0 {name=l122 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 6250 0 0 {name=p65 lab=in29















}
C {transmission_gate.sym} 570 6460 0 0 {name=x91 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 6410 2 1 {name=x92 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 6500 2 0 {name=l123 sig_type=std_logic lab=en30_b
}
C {devices/lab_pin.sym} 840 6340 2 0 {name=l124 sig_type=std_logic lab=en30_b
}
C {devices/lab_pin.sym} 600 6420 0 0 {name=l125 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 6500 0 0 {name=l126 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 6460 0 0 {name=p66 lab=in30















}
C {transmission_gate.sym} 570 6670 0 0 {name=x94 VDD=VDD VSS=VSS N=1 W_N=5.3 L_N=0.15 W_P=13.7 L_P=0.15}
C {switch_5t.sym} 770 6620 2 1 {name=x95 VDD=VDD VSS=VSS}
C {devices/lab_pin.sym} 840 6710 2 0 {name=l127 sig_type=std_logic lab=en31_b
}
C {devices/lab_pin.sym} 840 6550 2 0 {name=l128 sig_type=std_logic lab=en31_b
}
C {devices/lab_pin.sym} 600 6630 0 0 {name=l129 sig_type=std_logic lab=en_b}
C {devices/lab_pin.sym} 600 6710 0 0 {name=l130 sig_type=std_logic lab=en
}
C {devices/ipin.sym} 420 6670 0 0 {name=p67 lab=in31















}
C {devices/ipin.sym} 90 1330 0 0 {name=p68 lab=VDD
}
C {devices/ipin.sym} 90 1360 0 0 {name=p69 lab=VSS
}
C {sky130_stdcells/inv_1.sym} 840 270 1 0 {name=x97 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 470 1 0 {name=x22 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 670 1 0 {name=x25 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 870 1 0 {name=x58 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 1070 1 0 {name=x4 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 1270 1 0 {name=x7 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 1470 1 0 {name=x10 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 1670 1 0 {name=x13 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 1870 1 0 {name=x16 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 6590 1 0 {name=x19 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 6380 1 0 {name=x30 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 6170 1 0 {name=x33 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 5960 1 0 {name=x36 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 5750 1 0 {name=x39 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 5540 1 0 {name=x42 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 5330 1 0 {name=x45 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 5120 1 0 {name=x48 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 4910 1 0 {name=x51 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 4700 1 0 {name=x54 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 4280 1 0 {name=x57 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 4070 1 0 {name=x63 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 3870 1 0 {name=x69 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 3670 1 0 {name=x72 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 3470 1 0 {name=x75 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 3270 1 0 {name=x78 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 3070 1 0 {name=x81 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 2870 1 0 {name=x84 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 2670 1 0 {name=x87 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 2470 1 0 {name=x90 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 2270 1 0 {name=x93 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 2070 1 0 {name=x96 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 840 4490 1 0 {name=x61 VGND=VSS VNB=VSS VPB=VDD VPWR=VDD prefix=sky130_fd_sc_hd__ }
