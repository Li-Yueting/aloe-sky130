v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/users/lyt1314/ee372/aloe-sky130/analog_mux/schematic/analog_mux.sym} 700 -310 0 0 {name=x1}
