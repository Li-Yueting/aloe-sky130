v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 4420 2860 0 0 {name=p1 lab=VDD
}
C {devices/ipin.sym} 4420 2880 0 0 {name=p2 lab=VSS
}
C {devices/ipin.sym} 4420 2910 0 0 {name=p3 lab=a[4:0]
}
C {devices/ipin.sym} 4420 2940 0 0 {name=p4 lab=en
}
C {devices/opin.sym} 4400 2970 0 0 {name=p5 lab=y[31:0]}
