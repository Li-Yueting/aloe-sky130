$ Spice netlist generated by v2lvs
$ v2019.1_18.11    Thu Jan 10 13:52:35 PST 2019
.INCLUDE "inputs/adk/stdcells.spi"
.INCLUDE "source.added"
*.BUSDELIMITER [

.SUBCKT ringosc va vb vc vbg VSS VDD
XM17 VDD VDD va VSS VDD sky130_asc_pfet_01v8_lvt_12
XM1 vc VDD va VSS VDD sky130_asc_pfet_01v8_lvt_60
XM2 vc VDD vb VSS VDD sky130_asc_pfet_01v8_lvt_60
XM3 vc VDD vbg VSS VDD sky130_asc_pfet_01v8_lvt_60
.ENDS
