bandgap reference circuit - calculate parameter coefficients using transfer function analysis
.include outputs/design_parasitic_extracted.spice
