

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO bgr_top 
  PIN porst 
  END porst
  PIN va 
    ANTENNADIFFAREA 82.639 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 14.1024 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 75.208 LAYER met3 ;
  END va
  PIN vb 
    ANTENNADIFFAREA 57.9855 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 15.2064 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 81.096 LAYER met3 ;
  END vb
  PIN vbg 
    ANTENNADIFFAREA 57.9855 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 19.7424 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 105.768 LAYER met3 ;
  END vbg
END bgr_top

END LIBRARY
