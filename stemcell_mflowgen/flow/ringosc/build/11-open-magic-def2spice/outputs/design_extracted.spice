* NGSPICE file created from ringosc.ext - technology: sky130A

* Black-box entry subcircuit for sky130_asc_cap_mim_m3_1 abstract view
.subckt sky130_asc_cap_mim_m3_1 Cout Cin VPWR VGND
.ends

.subckt ringosc VDD
XC1 C1/Cout VDD VDD VDD sky130_asc_cap_mim_m3_1
.ends
