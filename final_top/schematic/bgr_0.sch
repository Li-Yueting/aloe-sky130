v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 4850 2870 0 0 {name=p1 lab=porst[0]}
C {devices/opin.sym} 4880 2900 0 0 {name=p2 lab=out_vbgr[0]}
C {devices/opin.sym} 4880 2930 0 0 {name=p3 lab=out_va[0]}
C {devices/opin.sym} 4880 2960 0 0 {name=p4 lab=out_vb[0]}
C {devices/ipin.sym} 4850 2820 0 0 {name=p7 lab=VDD}
C {devices/ipin.sym} 4850 2840 0 0 {name=p5 lab=VSS}
